# Repository YskSt030/Eagle

## EAGLE design E-paper_Driver_32seg/Utable_epaper_32seg_rev2.brd

Parts:
01, 02, 03, 04, 05, 06, 07, 08, 09, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32: M02PTH; 1X02
C1, C7, C11, C12, C13, C14: 1u; C0603K
C2: 1u; C0603
C3, C4: 22p; C0603K
C5, C6, C8, C10: 0.1u; C0603K
C9: 22u; C0805K
D1: CD1206-S01575; 1206
D2], D3: GREEN; LED-0603
D4, D5: Yellow; LED-0603
GD: PINHD-1X1; 1X01
GND: PINHD-1X1; 1X01
IC1: ADG211ASO-16; SO-16
IC2: AAT3221IGV-3.3-T1; SOT23-5
JP2, JP3: PINHD-1X12; 1X12
Q1: MOSFET-NCHANNELBSS138; SOT23
Q2: MOSFET-PCHANNELIRLML2244; SOT23-3
R1: R-EU_R0603; R0603
R2, R3, R4, R15, R16, R28: 0; R0603
R5, R6, R9, R10, R19, R20, R21, R22, R24, R27: 10k; R0603
R7, R8: 22; R0603
R11, R12, R13, R14: 1k; R0603
R23: 5.6k; R0603
S1: SWITCH-MOMENTARY-2SMD; TACTILE-SWITCH-SMD
U1: RN4142XV-DS; XBEE
U$1: USB_MICRO_FCI
U$2: MAU109
U$3, U$4, U$5, U$6, U$10, U$11, U$12, U$13: ADG1334; SSOP20
U$7: ATMEGA32U4-AU; TQFP44
U$8, U$9: PCA9635
U$14: FB; 0603
Y1: 16MHz; OSCILLATOR-3225

Connections:
+3V3: C14.2, IC2.5 (OUT), JP2.12, U1.1 (VDD_3V3)
+5V: C5.1, C6.1, C7.2, C13.2, D1.2 (C), IC1.12 (VL), IC2.1 (IN), JP2.1, Q2.2 (S), R1.1, R2.1, R9.1, R12.2, R15.2, R16.2, R19.2, R20.2, R21.2, R27.2, U$7.2 (UVCC), U$7.7 (VBUS), U$7.14 (VCC), U$7.24 (AVCC), U$7.34 (VCC2), U$14.2
+15V: IC1.13 (VDD), IC1.15 (D2), R3.2, R28.2, U$3.16 (VDD), U$4.16 (VDD), U$5.16 (VDD), U$6.16 (VDD), U$10.16 (VDD), U$11.16 (VDD), U$12.16 (VDD), U$13.16 (VDD)
-15V: IC1.2 (D1), IC1.4 (VSS), R4.1, U$3.5 (VSS), U$4.5 (VSS), U$5.5 (VSS), U$6.5 (VSS), U$10.5 (VSS), U$11.5 (VSS), U$12.5 (VSS), U$13.5 (VSS)
A0: JP3.7, U$7.36 ((ADC7/TDI)PF7)
A1: JP3.8, U$7.37 ((ADC6/TDO)PF6)
A2: JP3.9, U$7.38 ((ADC5/TMS)PF5)
A3: JP3.10, U$7.39 ((ADC4/TCK)PF4)
A4: JP3.11, U$7.40 ((ADC1)PF1)
A5: JP3.12, U$7.41 ((ADC0)PF0)
D0/RX: JP2.5, R22.2, U$7.20 ((RXD1/INT2)PD2)
D1/TX: JP2.4, R23.1, U$7.21 ((TXD1/INT3)PD3)
D5: JP3.6, U$7.31 ((OC3A/OC4A)PC6)
D6: JP3.2, U$7.27 ((T0/OC4D/ADC10)PD7)
D7: JP2.7, U$7.1 ((INT6/AIN0)PE6)
EN: IC1.1 (IN1), IC1.16 (IN2), U$7.25 ((ICP1/ADC8)PD4)
EN_15V: IC1.14 (S2), U$3.4 (S1B), U$3.7 (S2B), U$3.14 (S3B), U$3.17 (S4B), U$4.4 (S1B), U$4.7 (S2B), U$4.14 (S3B), U$4.17 (S4B), U$5.4 (S1B), U$5.7 (S2B), U$5.14 (S3B), U$5.17 (S4B), U$6.4 (S1B), U$6.7 (S2B), U$6.14 (S3B), U$6.17 (S4B), U$10.4 (S1B), U$10.7 (S2B), U$10.14 (S3B), U$10.17 (S4B), U$11.4 (S1B), U$11.7 (S2B), U$11.14 (S3B), U$11.17 (S4B), U$12.4 (S1B), U$12.7 (S2B), U$12.14 (S3B), U$12.17 (S4B), U$13.4 (S1B), U$13.7 (S2B), U$13.14 (S3B), U$13.17 (S4B)
EN_-15V: IC1.3 (S1), U$3.2 (S1A), U$3.9 (S2A), U$3.12 (S3A), U$3.19 (S4A), U$4.2 (S1A), U$4.9 (S2A), U$4.12 (S3A), U$4.19 (S4A), U$5.2 (S1A), U$5.9 (S2A), U$5.12 (S3A), U$5.19 (S4A), U$6.2 (S1A), U$6.9 (S2A), U$6.12 (S3A), U$6.19 (S4A), U$10.2 (S1A), U$10.9 (S2A), U$10.12 (S3A), U$10.19 (S4A), U$11.2 (S1A), U$11.9 (S2A), U$11.12 (S3A), U$11.19 (S4A), U$12.2 (S1A), U$12.9 (S2A), U$12.12 (S3A), U$12.19 (S4A), U$13.2 (S1A), U$13.9 (S2A), U$13.12 (S3A), U$13.19 (S4A)
EP1: 02.1, U$13.3 (D1)
EP2: 03.1, U$13.8 (D2)
EP3: 07.1, U$13.18 (D4)
EP4: 06.1, U$13.13 (D3)
EP5: 05.1, U$6.3 (D1)
EP6: 04.1, U$6.8 (D2)
EP7: 01.1, U$6.13 (D3)
EP8: 08.1, U$6.18 (D4)
EP9: 13.1, U$12.3 (D1)
EP10: 14.1, U$12.8 (D2)
EP11: 09.1, U$12.13 (D3)
EP12: 10.1, U$12.18 (D4)
EP13: 12.1, U$5.3 (D1)
EP14: 11.1, U$5.8 (D2)
EP15: 15.1, U$5.13 (D3)
EP16: 16.1, U$5.18 (D4)
EP17: 29.1, U$3.3 (D1)
EP18: 28.1, U$3.8 (D2)
EP19: 25.1, U$3.13 (D3)
EP20: 32.1, U$3.18 (D4)
EP21: 19.1, U$10.3 (D1)
EP22: 20.1, U$10.8 (D2)
EP23: 23.1, U$10.13 (D3)
EP24: 24.1, U$10.18 (D4)
EP25: 22.1, U$4.3 (D1)
EP26: 21.1, U$4.8 (D2)
EP27: 17.1, U$4.13 (D3)
EP28: 18.1, U$4.18 (D4)
EP29: 30.1, U$11.3 (D1)
EP30: 31.1, U$11.8 (D2)
EP31: 26.1, U$11.13 (D3)
EP32: 27.1, U$11.18 (D4)
GND: 01.2, 02.2, 03.2, 04.2, 05.2, 06.2, 07.2, 08.2, 09.2, 10.2, 11.2, 12.2, 13.2, 14.2, 15.2, 16.2, 17.2, 18.2, 19.2, 20.2, 21.2, 22.2, 23.2, 24.2, 25.2, 26.2, 27.2, 28.2, 29.2, 30.2, 31.2, 32.2, C1.1, C2.2, C3.2, C4.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, D2].C, D3.C, D4.C, D5.C, GD.1, GND.1, IC1.5 (GND), IC2.2 (GND), JP2.3, Q1.2 (S), R5.1, R6.1, R10.2, R24.2, S1.3 (2), U1.10 (GND), U$1.GND, U$1.P$6 (MTN1), U$1.P$7 (MTN2), U$1.P$8 (MTN3), U$1.P$9 (MTN4), U$2.P$2 (-VIN), U$2.P$5 (COM), U$3.6 (GND), U$4.6 (GND), U$5.6 (GND), U$6.6 (GND), U$7.5 (UGND), U$7.15 (GND), U$7.23 (GND2), U$7.35 (GND3), U$7.43 (GND4), U$8.1 (A0), U$8.2 (A1)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
IN3-1: U$3.1 (IN1), U$9.10 (LED4)
IN3-2: U$3.10 (IN2), U$9.9 (LED3)
IN3-3: U$3.11 (IN3), U$9.6 (LED0)
IN3-4: U$3.20 (IN4), U$9.11 (LED5)
IN4-1: U$4.1 (IN1), U$9.18 (LED11)
IN4-2: U$4.10 (IN2), U$9.19 (LED12)
IN4-3: U$4.11 (IN3), U$9.20 (LED13)
IN4-4: U$4.20 (IN4), U$9.15 (LED8)
IN5-1: U$5.1 (IN1), U$8.8 (LED2)
IN5-2: U$5.10 (IN2), U$8.10 (LED4)
IN5-3: U$5.11 (IN3), U$8.12 (LED6)
IN5-4: U$5.20 (IN4), U$8.6 (LED0)
IN6-1: U$6.1 (IN1), U$8.22 (LED15)
IN6-2: U$6.10 (IN2), U$8.18 (LED11)
IN6-3: U$6.11 (IN3), U$8.15 (LED8)
IN6-4: U$6.20 (IN4), U$8.21 (LED14)
IN10-1: U$9.22 (LED15), U$10.1 (IN1)
IN10-2: U$9.21 (LED14), U$10.10 (IN2)
IN10-3: U$9.17 (LED10), U$10.11 (IN3)
IN10-4: U$9.16 (LED9), U$10.20 (IN4)
IN11-1: U$9.12 (LED6), U$11.1 (IN1)
IN11-2: U$9.13 (LED7), U$11.10 (IN2)
IN11-3: U$9.7 (LED1), U$11.11 (IN3)
IN11-4: U$9.8 (LED2), U$11.20 (IN4)
IN12-1: U$8.9 (LED3), U$12.1 (IN1)
IN12-2: U$8.7 (LED1), U$12.10 (IN2)
IN12-3: U$8.13 (LED7), U$12.11 (IN3)
IN12-4: U$8.11 (LED5), U$12.20 (IN4)
IN13-1: U$8.16 (LED9), U$13.1 (IN1)
IN13-2: U$8.17 (LED10), U$13.10 (IN2)
IN13-3: U$8.19 (LED12), U$13.11 (IN3)
IN13-4: U$8.20 (LED13), U$13.20 (IN4)
IO8: JP3.3, U$7.28 ((PCINT4/ADC11)PB4)
IO9: JP3.4, U$7.29 ((PCINT5/OC1A/OC4B/ADC12)PB5)
IO10: JP3.5, U$7.30 ((PCINT6/OC1B/OC4B/ADC13)PB6)
IO11: JP2.6, U$7.12 ((PCINT7/OC0A/OC1C/RTS)PB7)
IO12: JP3.1, U$7.26 ((T1/OC4D/ADC9)PD6)
MISO: JP2.8, U$7.11 ((PDO/PCINT3/MISO)PB3)
MOSI: JP2.9, U$7.10 ((PDI/PCINT2/MOSI)PB2)
unnamed: C9.1, C10.1, R1.2, U$1.VBUS
unnamed: C4.2, U$7.17 (XTAL1), Y1.P$3 (2)
unnamed: R7.2, U$1.D-
unnamed: R8.2, U$1.D+
unnamed: C2.1, R2.2, U$2.P$1 (+VIN)
unnamed: R3.1, R5.2, U$2.P$6 (+VOUT)
unnamed: R4.2, R6.2, U$2.P$4 (-VOUT)
unnamed: C3.1, U$7.16 (XTAL2), Y1.P$1 (1)
unnamed: D1.1 (A), R9.2, S1.1, U$7.13 (RESET)
unnamed: C1.2, U$7.6 (UCAP)
unnamed: C8.2, U$7.42 (AREF)
unnamed: D5.A, R13.2
unnamed: U$7.44 (AVCC2), U$14.1
unnamed: R13.1, U$7.22 ((XCK1/CTS)PD5)
unnamed: R14.1, U$7.32 ((ICP3/CLK0/OC4A)PC7)
unnamed: D2].A, R14.2
unnamed: D4.A, R11.2
unnamed: D3.A, R12.1
unnamed: R10.1, U$7.33 ((HWB)PE2)
unnamed: R22.1, U1.2 (TXD)
unnamed: IC2.3 (XEN/EN), R21.1
unnamed: R23.2, R24.1, U1.3 (RXD)
unnamed: Q1.3 (D), Q2.1 (G), R27.1
unnamed: Q1.1 (G), R28.1
RD+: R8.1, U$7.4 (D+)
RD-: R7.1, U$7.3 (D-)
RXLED/SS: JP2.11, R11.1, U$7.8 ((SS/PCINT0)PB0)
SCK: JP2.10, U$7.9 ((PCINT1/SCLK)PB1)
SCL: R19.1, U$7.18 ((OSC0B/SCL/INT0)PD0), U$8.26 (SCL), U$9.26 (SCL)
SDA: R20.1, U$7.19 ((SDA/INT1)PD1), U$8.27 (SDA), U$9.27 (SDA)
VPP: C11.2, C12.2, Q2.3 (D), R15.1, R16.1, U$8.5 (A4), U$8.25 (A6), U$8.28 (VDD), U$9.4 (A3), U$9.25 (A6), U$9.28 (VDD)

Notes on the sheet:
Arduino Micro compatible
FUSE 500mA
Forbidden Slave Address: • ‘PCA9635 LED All Call address (1110 000) • ‘Software Reset (0000 0110) • ‘reserved for future use’ I2C-bus addresses (0000 011, 1111 1XX) • 10-bit addressing scheme (1111 0XX) • General Call address (0000 000) • High-speed mode master code (0000 1XX)
Address 0x48
Address 0x50

Board: 2 copper layers, 48.0 x 75.0 mm, 100 parts (28 on the bottom side), 121 nets.

## EAGLE design Energy-Harvest-trial/Eharvest.brd

Parts:
C9: 4.7u; C0402K
D1: 1N4728; DO41Z10
D5, D7: MBS-1(B-DIODE)
D8, D9: DIODE-SOD123; SOD123
J7, J8, J9: HEADER-2P-65/35MIL; 2P-2.54-65/35MIL
S1, S3: 9450-2
U$1, U$2: BV20_1P1S; BV20
U$3, U$4: MICELECTRET_SMD; MIC_ELECTRET_SMD

Connections:
ACIN3: D5.~ (AC1), J7.2
ACIN4: D5.~1 (AC2), J7.1
ACIN5: D7.~ (AC1), J9.2
ACIN6: D7.~1 (AC2), J9.1
GND2: C9.2, D1.A, D5.-, D7.-, S1.5, S3.5
unnamed: C9.1, D1.C, D8.C, D9.C, S1.2, S3.2
unnamed: J8.1, S1.4 (S), S3.1 (S)
unnamed: J8.2, S1.1 (S), S3.6 (O)
unnamed: D5.+, D8.A
unnamed: U$1.1, U$3.2
unnamed: U$1.4 (P2), U$3.1
unnamed: U$2.1, U$4.2
unnamed: U$2.4 (P2), U$4.1
unnamed: D7.+, D9.A

Notes on the sheet:
SANSUI ST-32
TO Epaper
DIODE ZENER 15V 1W SMA
SBD
2極双投 AB-25AP
ライターの 点火装置
Yusuke Sato
ここは2極単投でもよかったのですが 部品がなかったので
そこそこの巻き数比で インピーダンスが低ければ 何でもよいと思います

Board: 2 copper layers, 46.5 x 72.0 mm, 15 parts (0 on the bottom side), 14 nets.

## Commit log

2018-05-26 Add Initial Circuit Data

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
